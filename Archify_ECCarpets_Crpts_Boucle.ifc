Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2025-10-14T09:29:32
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Boucle_Atticus4318, Floor:Archify_ECCarpets_Carpets_Boucle_Atticus4318:221977
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Boucle_Atticus4318 9 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Atticus 4318; ModelReference: Boucle; Name: Carpets_Boucle_Atticus4318_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Boucle_Atticus4318; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/boucle/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Boucle_Coco4336, Floor:Archify_ECCarpets_Carpets_Boucle_Coco4336:222597
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Boucle_Coco4336 9 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Coco 4336; ModelReference: Boucle; Name: Carpets_Boucle_Coco4336_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Boucle_Coco4336; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/boucle/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Boucle_Fredrik4348, Floor:Archify_ECCarpets_Carpets_Boucle_Fredrik4348:222613
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Boucle_Fredrik4348 9 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Fredrik 4348; ModelReference: Boucle; Name: Carpets_Boucle_Fredrik4348_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Boucle_Fredrik4348; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/boucle/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Boucle_Jaqueline4342, Floor:Archify_ECCarpets_Carpets_Boucle_Jaqueline4342:222627
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Boucle_Jaqueline4342 9 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Jaqueline 4342; ModelReference: Boucle; Name: Carpets_Boucle_Jaqueline4342_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Boucle_Jaqueline4342; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/boucle/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Boucle_Maymo4308, Floor:Archify_ECCarpets_Carpets_Boucle_Maymo4308:222643
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Boucle_Maymo4308 9 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Maymo 4308; ModelReference: Boucle; Name: Carpets_Boucle_Maymo4308_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Boucle_Maymo4308; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/boucle/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Boucle_Mokum4347, Floor:Archify_ECCarpets_Carpets_Boucle_Mokum4347:222661
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Boucle_Mokum4347 9 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Mokum 4347; ModelReference: Boucle; Name: Carpets_Boucle_Mokum4347_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Boucle_Mokum4347; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/boucle/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Boucle_Ovie4304, Floor:Archify_ECCarpets_Carpets_Boucle_Ovie4304:222677
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Boucle_Ovie4304 9 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Ovie 4304; ModelReference: Boucle; Name: Carpets_Boucle_Ovie4304_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Boucle_Ovie4304; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/boucle/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Boucle_Sarinen4303, Floor:Archify_ECCarpets_Carpets_Boucle_Sarinen4303:222691
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Boucle_Sarinen4303 9 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Sarinen 4303; ModelReference: Boucle; Name: Carpets_Boucle_Sarinen4303_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Boucle_Sarinen4303; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/boucle/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Boucle_Shu4315, Floor:Archify_ECCarpets_Carpets_Boucle_Shu4315:222707
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Boucle_Shu4315 9 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Shu 4315; ModelReference: Boucle; Name: Carpets_Boucle_Shu4315_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Boucle_Shu4315; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/boucle/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
